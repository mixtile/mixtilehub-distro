require mixtilehub.inc

SUMMARY = "Small console image for mixtilehub"
IMAGE_LINGUAS = "en-us"
